# Keil uVision project EC_TEST1.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EC_TEST1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: EC_TEST1_22000814.c
  group HAL
    ../include/: ecEXTI2.c ecEXTI2.h ecGPIO2_student.c ecGPIO2_student.h ecPinNames.c ecPinNames.h ecPWM2.c ecPWM2.h ecRCC2.c ecRCC2.h ecSysTick2.c ecSysTick2.h ecTIM2.c ecTIM2.h ecUART2_simple_student.h ecUART2_simple_student.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
